FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://0001-Layer-config-landscape-support.patch \
    file://0001-Backport-webOS-OSE-changes-on-ff.patch \
"
